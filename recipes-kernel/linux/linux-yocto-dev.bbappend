FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require unit-networking.inc
