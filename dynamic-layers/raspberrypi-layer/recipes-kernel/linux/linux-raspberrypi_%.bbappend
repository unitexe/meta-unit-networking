FILESEXTRAPATHS:prepend := "${UNIT_NETWORKING_LAYERDIR}/recipes-kernel/linux/files:"

require recipes-kernel/linux/unit-networking.inc
